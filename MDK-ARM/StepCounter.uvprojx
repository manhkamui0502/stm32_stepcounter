# Keil uVision project StepCounter.uvprojx, settings and files
target StepCounter (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: StepCounter +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;..\CMSIS\Device\ST\STM32F1xx\Include;../Drivers/CMSIS/Include;../Core/Src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Inc
    ./: startup_stm32f103xb.s
    ../Core/Inc/: filter.h fonts.h gpio.h i2c.h main.h mpu6050.h rcc.h ssd1306.h stm32_def.h stm32f103c8t6.h tim2.h
  group Core
    ../Core/Src/: fonts.c ssd1306.c mpu6050.c filter.c main.c gpio.c i2c.c rcc.c stm32f103c8t6.c tim2.c system_stm32f1xx.c
  group Devices
    ../CMSIS/Device/ST/STM32F1xx/Include/: stm32f1xx.h
software components: CMSIS:CORE 5.6.0
